# Keil uVision project Am32G071.uvprojx, settings and files
target Templates_LL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Templates_LL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: ../Inc;../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group startup
    ./mcu/g071/Startup/: startup_stm32g071xx.s
  group g071
    ./mcu/g071/mcusrc/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32g0xx_it.c system_stm32g0xx.c WS2812.c
  group Src
    ./src/: dshot.c firmwareversion.c functions.c main.c signal.c sounds.c
  group Drivers
    ./mcu/g071/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
target AM32_G071 (6160000::V6.16::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: Templates_LL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GEN_64K_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: .\inc;.\mcu\g071\mcuinc;.\mcu\g071\Drivers\CMSIS\Include;.\mcu\g071\Drivers\STM32G0xx_HAL_Driver\Inc;.\mcu\g071\Drivers\CMSIS\Device\ST\STM32G0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Objects\Am32_64kb_g071.sct
software components: CMSIS:CORE 5.5.0
