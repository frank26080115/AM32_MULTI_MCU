# Keil uVision project Project.uvprojx, settings and files
target AM32REF_F051 (6160000::V6.16::ARMCLANG)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AM32REF_F051 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_FULL_LL_DRIVER, AM32REF_F051
  c include: .\mcu\f051\Drivers\CMSIS\Include;.\mcu\f051\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\mcu\f051\Drivers\STM32F0xx_HAL_Driver\Inc;.\mcu\f051\mcuinc;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\Am32 32kb_f051.sct
  group startup
    ./mcu/f051/Startup/: startup_stm32f051k8.s
  group Src
    ./src/: dshot.c firmwareversion.c functions.c main.c signal.c sounds.c
  group f051
    ./mcu/f051/mcusrc/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32f0xx_it.c system_stm32f0xx.c
  group Drivers/STM32F0xx_LL_Driver
    ./mcu/f051/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
software components: CMSIS:CORE 5.5.0
